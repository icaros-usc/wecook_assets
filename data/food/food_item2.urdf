Commit message: mark for icra2

File: data/food/food_item2.urdf (robot description, URDF)
Before this commit: robot food_item, 1 links, 0 joints
Links:
- link food_item: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
