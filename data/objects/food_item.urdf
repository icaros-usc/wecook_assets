Commit message: scale food item and pot

File: data/objects/food_item.urdf (robot description, URDF)
Before this commit: robot food_item, 1 links, 0 joints
Links:
- link food_item: geometry collision box size=0.1 0.1 0.045; visual box size=0.1 0.1 0.045
