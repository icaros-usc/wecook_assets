Commit message: added ham sandwich objects

File: data/food/pasta.urdf (robot description, URDF)
Before this commit: robot pasta, 1 links, 0 joints
Links:
- link pasta: geometry collision mesh filename=pasta.dae scale=0.05 0.035 0.05; visual mesh filename=pasta.dae scale=0.05 0.035 0.05
